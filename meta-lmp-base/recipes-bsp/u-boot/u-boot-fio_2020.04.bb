require u-boot-fio-common.inc

SRCREV = "${AUTOREV}"
#SRCBRANCH = "2020.04+fio"
SRCBRANCH = "secondary_boot_handling"
