require optee-os-fio.inc

PV = "3.12.0+git"
SRCREV = "32b28ab0951f77d3d8329f644d1005f44ac96cd2"
SRCBRANCH = "3.12+fio"
