require optee-os-fio.inc

PV = "3.10.0+git"
SRCREV = "${AUTOREV}"
SRCBRANCH = "3.10+fio"
